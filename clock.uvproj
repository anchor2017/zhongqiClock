# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 calTimeDisplay.c clock.c DS18S120.C gui.c gy521.c i2c.c lcd_driver.c main.c paintTFT.c settime.c touch.c
