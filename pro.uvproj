# Keil uVision project pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pro +hex
  c flags: Optimize=9
  group Source Group 1
    ./: main.c lcd_driver.c gui.c touch.c charcode.h calTimeDisplay.c calTimeDisplay.h paintTFT.c paintTFT.h clock.c clock.h i2c.c gy521.c pwm.c DS18S120.C settime.c
